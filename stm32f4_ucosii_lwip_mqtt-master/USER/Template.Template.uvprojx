# Keil uVision project Template.Template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=4 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ../CORE;../FATFS/exfuns;../FATFS/src;../FWLIB/STM32F4x7_ETH_Driver/inc;../FWLIB/STM32F4xx_StdPeriph_Driver/inc;../HARDWARE/DCMI;../HARDWARE/DS18B20;../HARDWARE/ETHERNET;../HARDWARE/IIC;../HARDWARE/KEY;../HARDWARE/LCD;../HARDWARE/LED;../HARDWARE/OV2640;../HARDWARE/SDIO;../HARDWARE/SHT30;../HARDWARE/SPI;../HARDWARE/SRAM;../HARDWARE/STMFLASH;../HARDWARE/TIMER;../HARDWARE/U2GBK;../HARDWARE/W25QXX;../LWIP;../LWIP/arch;../LWIP/lwip-1.4.1/src/include;../LWIP/lwip-1.4.1/src/include/ipv4;../LWIP/lwip-1.4.1/src/include/lwip;../LWIP/lwip-1.4.1/src/include/netif;../LWIP/lwip_app/lwip_comm;../LWIP/lwip_app/tcp_client;../LWIP/lwip_app/web_server_demo;../LWIP/lwip_header;../MALLOC;../PICTURE;../SYSTEM/commit;../SYSTEM/delay;../SYSTEM/exit;../SYSTEM/sys;../SYSTEM/usart;../SYSTEM/usart2;../TEXT;../UCOSII/CONFIG;../UCOSII/CORE;../UCOSII/PORT;../USER;../USMART;../mqtt/app;../mqtt/cjson;../mqtt/hmac_sha1/hmac;../mqtt/hmac_sha1/sha;../mqtt/src;../mqtt/transport;d:/Keil_v5/ARM/CMSIS/Include
  asm include: :/Keil_v5/ARM/CMSIS/Include
  memory RVCT4: RAM 0x8000000 size 0x100000
  memory RVCT9: ROM 0x20000000 size 0x20000
  memory RVCT10: ROM 0x10000000 size 0x10000
  scatter file: ./Template.Template.sct
  link misc: --entry=Reset_Handler --info summarysizes --load_addr_map_info --summary_stderr
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/ETHERNET/: LAN8720.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/U2GBK/: U2GBK.c
    ../TEXT/: text.c fontupd.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/OV2640/: sccb.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/SHT30/: sht30.c
    ../HARDWARE/IIC/: myiic.c
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_fsmc.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_dcmi.c stm32f4xx_flash.c
    ../FWLIB/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/exit/: exit.c
    ../SYSTEM/commit/: commit.c
    ../SYSTEM/usart2/: usart2.c
  group LWIP-APP
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../LWIP/lwip_app/tcp_client/: tcp_client.c
    ../LWIP/lwip_app/web_server_demo/: fs.c httpd.c httpd_cgi_ssi.c
  group LWIP-NETIF
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP-CORE
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c mem.c
  group LWIP-ARCH
    ../LWIP/arch/: sys_arch.c
  group LWIP-API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group UCOSII_CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII_PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOSII_CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group MALLOC
    ../MALLOC/: malloc.c
  group mqtt/app
    ../mqtt/app/: mqtt_app.c
  group mqtt/src
    ../mqtt/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group mqtt/transport
    ../mqtt/transport/: transport.c
  group mqtt/hmac_sha1
    ../mqtt/hmac_sha1/sha/: sha1.c
    ../mqtt/hmac_sha1/hmac/: hmac_sha1.c
  group mqtt/cjson
    ../mqtt/cjson/: cJSON.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ../FATFS/src/: diskio.c ff.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group PICTURE
    ../PICTURE/: bmp.c gif.c piclib.c tjpgd.c
